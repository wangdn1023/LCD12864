# Keil uVision project 工程模板.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\APP;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\SysTick;.\APP\LCD12864;.\APP\key;.\APP\DCMotor;.\APP\ADC;.\APP\exit;.\APP\AT24Cxx;.\APP\IIC(24C02);.\APP\nrf24l01;.\APP\spi;.\APP\PWM;.\APP\time
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stdperiph_Drive
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_exti.c misc.c stm32f10x_spi.c stm32f10x_tim.c
  group APP
    ./APP/SysTick/: systick.c
    ./APP/LCD12864/: LCD12864.c
    ./APP/key/: key.c
    ./APP/DCMotor/: DCMotor.c
    ./APP/ADC/: adc.c
    ./APP/exit/: exti.c
    ./APP/AT24Cxx/: AT24CXX.c
    ./APP/IIC(24C02)/: iic.c
    ./APP/spi/: spi.c
    ./APP/nrf24l01/: nrf24l01.c
    ./APP/PWM/: pwm.c
    ./APP/time/: time.c
software components: CMSIS:CORE 5.2.0
